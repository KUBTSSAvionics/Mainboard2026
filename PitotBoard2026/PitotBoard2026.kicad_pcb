# Repository KUBTSSAvionics/Mainboard2026

## KiCad design PitotBoard2026/PitotBoard2026.kicad_pcb

Parts:
C1, C4, C14, C16, C18, C20, C22, C24: 0.1u; C_0603_1608Metric
C2, C5, C6, C7, C9, C15, C17, C19, C21: 1u; C_0603_1608Metric
C3, C8, C23: 10u; C_0603_1608Metric
C10, C11, C12: 4.7u; C_0603_1608Metric
C27: 100n; C_0603_1608Metric
D1, D2, D6: RB160M; D_SOD-123
D5: ERR; LED_0603_1608Metric
FB1: FerriteBead_Small; L_0603_1608Metric
J1: RJ25; RJ25_Wayconn_MJEA-660X1_Horizontal
J2: ICSP; PinHeader_2x03_P2.54mm_Vertical
J3, J5: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Vertical
J4, J6: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Horizontal
L1: 10uH; L_Changjiang_FTC322512S
R1, R18: 10k; R_0603_1608Metric
R9: 120; R_0603_1608Metric
R10: 1k; R_0603_1608Metric
R11, R12, R20, R21, R22, R23: 4.7k; R_0603_1608Metric
R13: 10; R_0603_1608Metric
R14: 100; R_0603_1608Metric
R17: 100k; R_0603_1608Metric
SW1: RST; SW_SPST_PTS810
U1: ATmega328PB-A; TQFP-32_7x7mm_P0.8mm
U2: M78AR05-0.5; SIP3_11.6x8.5mm
U3: SDP32
U4, U7: SLIP; SOIC-8_3.9x4.9mm_P1.27mm
U5: TPS76133SF5; SOT-23-5
U9: BME280
U10: MCP25625-x-SS; SSOP-28_5.3x10.2mm_P0.65mm
U11: FXMA2102; DIP-8_W7.62mm
Y1, Y3: 16MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3V3: C7.1, D6.2 (A), J5.2, R22.1, R23.1, U5.5 (OUT), U9.1 (VDD), U9.3 (CSB), U11.8 (VCCB)
+5V: C4.1, C6.1, C8.1, C16.2, C17.2, C19.1, C20.1, C21.1, C22.1, D2.2 (A), D6.1 (K), FB1.1, J2.5, J3.4, R1.1, R11.1, R12.1, R13.2, R18.2, R20.1, R21.1, U1.18 (AVCC), U2.3 (OUT), U4.1 (VDD5V), U5.1 (IN), U5.3 (~EN), U10.1 (VIO), U10.19 (VDD), U11.1 (VCCA), U11.4 (OE)
+5VA: C14.1, J4.4, U7.1 (VDD5V)
CANH: J1.4, R9.1, U10.4 (CANH)
CANL: J1.3, R9.2, U10.3 (CANL)
CS: U1.14 (PB2), U10.17 (~CS)
ERR: D5.2 (A), U1.11 (PD7)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C16.1, C17.1, C18.1, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, J1.2, J2.1, J3.1, J5.3, R10.2, R17.2, SW1.1, U1.5 (GND), U1.21 (GND), U2.2 (GND), U4.4 (GND), U4.5 (PGO), U4.8 (DIR), U5.2 (GND), U9.2 (GND), U9.5 (SDO), U10.10 (GND), U10.26 (VSS), U11.5 (GND), Y1.2, Y3.2
GND1: C14.2, C15.2, J4.1, U7.4 (GND), U7.5 (PGO), U7.8 (DIR)
GND2: C27.2, J6.3, U3.1 (GND), U3.2 (GND), U3.3 (GND), U3.6 (GND), U3.9 (ADDR), U3.10 (GND), U3.11 (GND), U3.17 (GND1), U3.18 (GND1)
INT: U1.1 (PD3), U10.13 (~INT)
MISO: J2.6, U1.16 (PB4), U10.16 (SO)
MOSI: J2.3, U1.15 (PB3), U10.15 (SI)
unnamed: D1.2 (A), J1.5
unnamed: C3.1, C9.1, C10.1, C11.1, D1.1 (K), D2.1 (K), L1.1
unnamed: D5.1 (K), R10.1
unnamed: J6.1, U3.8 (SDA)
unnamed: C27.1, J6.2, U3.7 (VDD)
unnamed: J6.4, U3.5 (SCL)
unnamed: C1.1, U1.20 (AREF)
unnamed: C2.2, C18.2, R13.1, U1.4 (VCC)
unnamed: U1.7 (XTAL1/PB6), Y1.3
unnamed: U1.8 (XTAL2/PB7), Y1.1
unnamed: R14.1, U1.29 (~RESET/PC6)
unnamed: C12.1, L1.2, U2.1 (IN)
unnamed: C5.1, U4.2 (VDD3V3)
unnamed: C15.1, U7.2 (VDD3V3)
unnamed: U10.9 (OSC1), Y3.1
unnamed: U10.8 (OSC2), Y3.3
unnamed: U10.21 (RxCAN), U10.28 (RXD)
unnamed: R17.1, U10.5 (STBY)
unnamed: U10.20 (TxCAN), U10.24 (TXD)
unnamed: C23.1, C24.1, FB1.2, U10.27 (VDDA)
unnamed: R18.1, U10.18 (~RESET)
RST: J2.2, R1.2, R14.2, SW1.2
SCK: J2.4, U1.17 (PB5), U10.14 (SCK)
SCL0: J3.2, R20.2, U1.6 (PE1), U11.2 (A0)
SCL1: R12.2, U1.28 (PC5), U4.7 (SCL)
SCL2: J4.2, U7.7 (SCL)
SCL3: J5.4, R22.2, U9.6 (CLK), U11.7 (B0)
SDA0: J3.3, R21.2, U1.3 (PE0), U11.3 (A1)
SDA1: R11.2, U1.27 (PC4), U4.6 (SDA)
SDA2: J4.3, U7.6 (SDA)
SDA3: J5.1, R23.2, U9.4 (SDI), U11.6 (B1)

Notes on the sheet:
B0 7 B1 6
C10～C12：データシートで高周波ノイズの発生を防ぐために必要とされてるコンデンサ ClassB
SDOピンをGNDに接続しているため、I2Cアドレスは0x76
I2Cアドレスは固定で0x36
0.125W
R5をはがす
max:150mA
書き込み用
max:500mA
こっちにTWIの2系統目があるので AS5600二つをI2C駆動してもよい
裏面のパッド（PCBエディターでパッド17、18）はGNDにする。

Board: 2 copper layers, 59.7 x 40.2 mm, 61 parts (20 on the bottom side), 44 nets.

## KiCad design MainBoard2026/MainBoard2026.kicad_pcb

Parts:
BT1: MS621FE FL11E; BatteryHolder_Seiko_MS621F
C2, C5, C13: 10u; C_0603_1608Metric
C3, C15, C21: 1u; C_0603_1608Metric
C4, C6, C7, C8, C14, C16, C23, C24, C27, C28: 0.1u; C_0603_1608Metric
C17: 100u; C_1206_3216Metric
C22, C25, C26, C29: 22u; C_0603_1608Metric
D1, D7, D9, D10: RB160M; D_SOD-123
D2: ERR2; LED_0603_1608Metric
D4: SD; LED_0603_1608Metric
D5: CAN; LED_0603_1608Metric
D6: ERR; LED_0603_1608Metric
D20: Zener_9V1; Zenner
F2: MF-R090; Fuse MF-R090
FB1: FerriteBead_Small; L_0603_1608Metric
J1, J2, J4: RJ25; RJ25_Wayconn_MJEA-660X1_Horizontal
J3: ICSP; PinHeader_2x03_P2.54mm_Vertical
J5: GPS_DFROBOT_TEL-0157; JST_XA_S04B-XASK-1_1x04_P2.50mm_Horizontal
J6: Micro_SD_Card_Det_Hirose_DM3AT; microSD_HC_Hirose_DM3AT-SF-PEJM5
J8: BATT_CON; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
JP1: Terminate; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1: AO3401A; SOT-23
R1, R3, R13: 10k; R_0603_1608Metric
R2, R7, R11: 1k; R_0603_1608Metric
R4, R19, R23, R25, R27, R42: 100k; R_0603_1608Metric
R5, R6: 2k; R_0603_1608Metric
R8: 22; R_0603_1608Metric
R9: 120; R_0603_1608Metric
R10: 330k; R_0603_1608Metric
R12: 47k; R_0603_1608Metric
R26: 200k; R_0603_1608Metric
R30, R31, R32: 33; R_0603_1608Metric
R44: 4.7k; R_0603_1608Metric
SW3: POWER; toggle
U1: ESP32-WROOM-32
U2: R-78E5.0-0.5; Converter_DCDC_RECOM_R-78E-0.5_THT
U3: MCP25625-x-SS; SSOP-28_5.3x10.2mm_P0.65mm
U4: BP5293-33
U5: BNO055
U6: RX8900_mod; DIP-8_W7.62mm
Y1: 16MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3V3: C3.1, C5.1, C6.2, C8.1, C13.2, C14.1, C15.1, C16.1, C17.1, C28.2, C29.2, D4.2 (A), D5.2 (A), D7.2 (A), D9.2 (A), D10.1 (K), J3.6, J5.1, J6.4 (VDD), R3.2, R4.1, R12.2, R19.2, R25.2, U1.2 (VDD), U3.1 (VIO), U3.19 (VDD), U4.3 (OUT), U5.1 (VIN), U6.8 (VDD)
+5V: C22.2, C23.2, D1.2 (A), FB1.1, U2.3 (OUT)
+BATT: C24.2, C25.2, C26.2, C27.2, D1.1 (K), D9.1 (K), J1.5, J2.5, J4.5, Q1.3 (D), R1.1, U2.1 (IN), U4.1 (IN)
CAN_H: J1.4, J2.4, J4.4, R9.1, U3.4 (CAN_H)
CAN_L: J1.3, J2.3, J4.3, JP1.1 (A), U3.3 (CAN_L)
CS: R6.2, U1.23 (IO15), U3.17 (~CS)
CS1: J6.2 (DAT3/CD), R5.2, R12.1, R30.2
DET: J6.9 (DET_B), U1.6 (IO34)
EN: J3.5, U1.3 (EN)
ERR: D6.2 (A), U1.11 (IO26)
ERR2: D2.2 (A), U1.12 (IO27)
GND: BT1.2 (-), C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C13.1, C14.2, C15.2, C16.2, C17.2, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, J1.2, J2.2, J3.2, J4.2, J5.2, J6.6 (VSS), J6.10 (DET_A), J6.11 (SHIELD), J8.1, R2.2, R7.2, R11.2, R13.2, R23.2, SW3.1 (A), U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.2 (GND), U3.10 (GND), U3.26 (VSS), U4.2 (GND), U5.2 (GND), U6.4 (GND), Y1.2
INT: U1.26 (IO4), U3.13 (~INT)
IO0: J3.3, U1.25 (IO0)
MISO: R8.2, U1.31 (IO19), U3.16 (SO)
MOSI: J6.3 (CMD), R4.2, R31.2, U3.15 (SI)
unnamed: BT1.1 (+), R10.2, U6.7 (VBAT)
unnamed: D2.1 (K), R11.1
unnamed: D4.1 (K), R5.1
unnamed: D5.1 (K), R6.1
unnamed: D6.1 (K), R7.1
unnamed: D7.1 (K), R10.1
unnamed: D10.2 (A), R26.1
unnamed: C21.1, D20.2 (A), Q1.1 (G), R44.2
unnamed: C21.2, D20.1 (K), F2.2, Q1.2 (S), R42.2, SW3.3 (C)
unnamed: J6.7 (DAT0), R8.1
unnamed: J6.1 (DAT2), J6.8 (DAT1), R19.1
unnamed: F2.1, J8.2
unnamed: JP1.2 (B), R9.2
unnamed: R42.1, R44.1, SW3.2 (B)
unnamed: R30.1, U1.29 (IO5)
unnamed: R13.1, U1.14 (IO12)
unnamed: R32.1, U1.30 (IO18)
unnamed: R31.1, U1.37 (IO23)
unnamed: C7.1, R27.2, U1.7 (IO35)
unnamed: U3.9 (OSC1), Y1.1
unnamed: U3.8 (OSC2), Y1.3
unnamed: U3.21 (RxCAN), U3.28 (RXD)
unnamed: R23.1, U3.5 (STBY)
unnamed: U3.20 (TxCAN), U3.24 (TXD)
unnamed: C2.1, C4.1, FB1.2, U3.27 (VDDA)
unnamed: R3.1, U3.18 (~RESET)
RX: J3.4, U1.34 (RXD0/IO3)
RX1: J5.4, U1.27 (IO16)
SCK: J6.5 (CLK), R32.2, U3.14 (SCK)
SCL: U1.36 (IO22), U5.4 (SCL/R), U6.6 (SCL)
SDA: U1.33 (IO21), U5.3 (SDA/T), U6.5 (SDA)
TX: J3.1, U1.35 (TXD0/IO1)
TX1: J5.3, R25.1, U1.28 (IO17)
VSENS: R1.2, R2.1, R26.2, R27.1

Notes on the sheet:
SdFat.h
ジャンパJ1でモジュール内I2Cプルアップする
RTCは極力時間を同期させるためにデータが多く集まるメイン基板に置く。
SDcardのSPIピンアサイン
VDD近くに配置
ピンについての説明
GPS基板を別に用意すると思うがスペースだけ設けておく
I2C SDA:IO21,SCL:IO22 SPI SCK:IO18,MISO:IO19,MOSI:IO23,CS:IO5, CS2:IO15 UART0(書き込み） TX:IO1,RX:IO3 UART1(未接続） UART2(外部機器） TX:IO17,RX16

Board: 2 copper layers, 65.0 x 67.4 mm, 73 parts (55 on the bottom side), 50 nets.

## Commit log

2025-09-17 Add files via upload
    Raspberry Pi Pico W からESP32に変更 2025.09.17
2025-10-01 Add files via upload
    CANコネクタを増やした
2025-10-03 Add files via upload
    試作前完成版
2025-10-25 Add files via upload
    試作後 抵抗値など修正 2025.10.25
2025-10-25 Add files via upload
    SDカードの書き込みとCANの接続テスト用コード
2025-10-27 GPSの接続テスト
    ジャンパー線を使おう。接続に問題があったときに気づけない。データシートだけでなくライブラリの実装も読もう。データの形式が特殊だった(ソフトウェアの実装はしやすい)。
2025-11-17 Add files via upload
    フットプリント設定完了
2025-12-25 Add files via upload
    配線完了
2026-02-10 Add files via upload
    入江さんのフィードバックを回路図に反映
2026-04-28 Add files via upload
    AO3401Aのフットプリントを修正
2026-05-27 Add files via upload
    MCP25625のピン19を3V3に変更
2026-05-27 Add files via upload
    MCP25625 ピン19を3V3に変更。取付穴を追加。
2026-05-27 Add files via upload
    MCP25625を5Vに修正。FXMA2102のピン番号を修正。
